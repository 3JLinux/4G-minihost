# IAR project Backup of contiki_os.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xD ST STM32F103xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; __ICCARM__
  ICCARM.CCDiagSuppress: Pa050,Pe177,Pe550
  ICCARM.CCIncludePath2: ..\StdPeriph_Driver\inc; ..\contiki\cpu\stm32F103; ..\contiki\platform\stm32f103; ..\xprintf; ..\contiki\core; ..\contiki\core\sys; ..\contiki\core\lib; ..\CMSIS; ..\contiki\core\net; ..\contiki\apps\shell; ..\contiki\cpu\stm32F103\si4438; ..\contiki\cpu\stm32F103\si4438\radiolib; ..\utility; ..\hwgg; ..\contiki\core\net\ip64; ..\contiki\core\net\ip64-addr; ..\grps; ..\app485; ..\app_sound_light_alarm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: contiki_os.hex
  ILINK.IlinkOutputFile: contiki_os.out
  ILINK.IlinkIcfFile: contiki_os_rdt6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: G:\contiki_IAR\contiki_os\StdPeriph_Driver\inc; G:\contiki_IAR\contiki_os\contiki\cpu\stm32F103; G:\contiki_IAR\contiki_os\contiki\platform\stm32f103; G:\contiki_IAR\contiki_os\xprintf; G:\contiki_IAR\contiki_os\contiki\core; G:\contiki_IAR\contiki_os\contiki\core\sys; G:\contiki_IAR\contiki_os\contiki\core\lib; G:\contiki_IAR\contiki_os\CMSIS
  group app485
    ../app485/: app485.c
  group appenc28j60
    ../appenc28j60/: appenc28j60.c
  group appSoundLight
    ../app_sound_light_alarm/: app_sound_light_alarm.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group contiki/apps/serial-shell
    ../contiki/apps/serial-shell/: serial-shell.c
  group contiki/apps/shell
    ../contiki/apps/shell/: shell.c
  group contiki/core/dev
    ../contiki/core/dev/: leds.c nullradio.c serial-line.c
  group contiki/core/lib
    ../contiki/core/lib/: crc16.c list.c memb.c mmem.c random.c ringbuf.c ringbufindex.c ringbufindex.h
  group contiki/core/net
    ../contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group contiki/core/net/ip
    ../contiki/core/net/ip/: dhcpc.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-debug.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group contiki/core/net/ip64
    ../contiki/core/net/ip64-addr/: ip64-addr.c
    ../contiki/core/net/ip64/: ip64-addrmap.c ip64-arp.c ip64-dhcpc.c ip64-eth-interface.c ip64-eth.c ip64-ipv4-dhcp.c ip64-null-driver.c ip64-slip-interface.c ip64-special-ports.c ip64.c
  group contiki/core/net/ipv6
    ../contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group contiki/core/net/llsec
    ../contiki/core/net/llsec/: anti-replay.c nullsec.c
  group contiki/core/net/mac
    ../contiki/core/net/mac/contikimac/: contikimac-framer.c contikimac.c
    ../contiki/core/net/mac/: csma.c frame802154.c framer-802154.c framer-nullmac.c framer.c mac-sequence.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group contiki/core/net/mac/sicslowmac
    ../contiki/core/net/mac/sicslowmac/: sicslowmac.c sicslowmac.h
  group contiki/core/rpl
    ../contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group contiki/core/sys
    ../contiki/core/sys/: arg.c autostart.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
  group contiki/cpu
    ../contiki/cpu/stm32F103/: arch_s.s arch_spi.c clock.c debug-uart.c eeflash.c leds-arch.c pulse.c rtimer-arch.c stm32f103_contiki_os.c stm32f10x_usart1.c sysprintf.c uart_dma.c utility.c watchdog.c
  group contiki/dev/enc28j60
    ../contiki/dev/enc28j60/: enc28j60-ip64-driver.c enc28j60-ip64-driver.h enc28j60.c enc28j60.h
  group contiki/platform/stm32f103
    ../contiki/platform/stm32f103/: contiki-main.c dev_info.c enc28j60_stm32f103.c stm32f10x_it.c
  group contiki/platform/stm32f103/userapp
    ../contiki/platform/stm32f103/: receiver-node.c root-node.c
  group FWLIB/inc
    ../StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group FWLIB/src
    ../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group gprs
    ../grps/: gprsProtocol.c sim900a.c
  group hhsj
    ../hhsj/: readme.txt
  group hwgg
    ../hwgg/: end_node_list.c fireNodeApp.c hwgg.c
  group keyled
    ../keyled/: appkey.c
  group mp3
    ../mp3/: mp3app.c
  group StartUp
    ../StartUp/: startup_stm32f10x_hd.s
  group utility
    ../utility/: common.c
  group xprintf
    ../xprintf/: xprintf.c
